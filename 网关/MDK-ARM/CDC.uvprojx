# Keil uVision project CDC.uvprojx, settings and files
target N32H480 (6240000::V6.24::ARMCLANG)
  device: N32H482RE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x30000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CDC +hex
  AfterMake: fromelf --bin --output=.\bin\CDC.bin .\Objects\CDC.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: N32H482, USE_STDPERIPH_DRIVER,BOARD_USE_HSE=1,HSE_VALUE=16000000U,LOG_ENABLE=1,FM_MAP_MODE=2,VECT_TAB_OFFSET=0x4000,MAIN_OTA_AUTO_REBOOT=1
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32h47x_48x_std_periph_driver\inc;..\bsp\inc;..\app\bsp;..\app\common;..\app\common\ring_buf;..\app\core;..\app\drivers\lora;..\app\drivers\xflash;..\app\links\g4;..\app\links\lora;..\app\links\serial;..\app\cloud;..\app\model;..\app\service;..\app\ota;..\app\log;..\app\cjson
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dbg.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_usart.c n32h47x_48x_tim.c n32h47x_48x_rtc.c n32h47x_48x_adc.c n32h47x_48x_spi.c
  group BSP
    ../bsp/inc/: delay.h log.h
    ../bsp/src/: delay.c
  group USER
    ../src/: main.c n32h47x_48x_it.c
  group inc
    ../inc/: main.h n32h47x_48x_it.h
  group DOC
    ../: readme.txt
  group app\bsp
    ../app/bsp/: bsp_gpio.c bsp_gpio.h bsp_tim.c bsp_tim.h bsp_uart.c bsp_uart.h
  group app\common
    ../app/common/: storage.c storage.h utils.c utils.h flash_map.h
  group app\common\ring_buf
    ../app/common/ring_buf/: ring_buf.c ring_buf.h
  group app\drivers\lora
    ../app/drivers/lora/: LLCC68N32H482-board.c llcc68-board.h radio.h llcc68.c llcc68.h project_config.h radio.c
  group app\links\g4
    ../app/links/g4/: g4_at.c g4_at.h g4_io.c g4_io.h g4_urc.c g4_urc.h
  group app\links\lora
    ../app/links/lora/: lora_business.c lora_unbind.c lora_bind.c lora_downlink.c lora_slave.c lora_internal.h lora_field.c lora_business.h lora_proto.c lora_proto.h
  group app\links\serial
    ../app/links/serial/: serial_proto.c serial_proto.h
  group app\cloud
    ../app/cloud/: cloud_json.c cloud_json.h cloud_proto.c cloud_internal.h cloud_uplink.c cloud_cmd_ota.c cloud_cmd_sys.c cloud_cmd_cfg.c cloud_cmd_devices.c cloud_proto.h
  group app\model
    ../app/model/: param_save.c param_save.h cloud_profile.c cloud_profile.h config_store.c config_internal.h config_serialize.c config_parse.c config_store.h last_value.c last_value.h
  group app\service
    ../app/service/: data_cache.c data_cache.h local_alarm.c local_alarm.h sensor_offline.c level_eval.c level_eval.h event_cache.c telemetry_cache.c telemetry_cache.h event_cache.h sensor_offline.h
  group app\ota
    ../app/ota/: ota_port.c ota_port.h md5.c md5.h ota_http.c ota_http.h ota_meta.h ota_mark.h ota_health.c ota_health.h
  group app\log
    ../app/log/: log.c xf_log.c
  group app\cjson
    ../app/cjson/: cJSON.c cJSON.h cjson_port.c cjson_port.h
  group app\core
    ../app/core/: app_state.c app_state.h app_config.h app_downlink.c app_mgmt.c app_mgmt.h app_uplink.c app_events.c app_modes.c app_boot.c app_loop.c app_core.h app_console.c
  group app\drivers\xflash
    ../app/drivers/xflash/: xflash.c xflash.h xflash_store.c xflash_store.h
target N32H48X (6240000::V6.24::ARMCLANG)
  device: N32H482RE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: as above
  output: CDC +hex
  AfterMake: fromelf --bin --output=.\bin\CDC.bin .\Objects\CDC.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: as above
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x30000
